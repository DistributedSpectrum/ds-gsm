options:
  parameters:
    author: Bradley C
    generate_options: qt_gui
    id: get_bcch_bladerf
    output_language: python
    title: 'GSM BCCH Decoder bladeRF/SigMF '
  states: {}

blocks:
- name: input_rx_freq
  id: variable_qtgui_entry
  parameters:
    gui_hint: 1,0,1,3
    label: 'RX Center Freq '
    type: real
    value: fc
  states: {}
- name: input_sigmf
  id: variable
  parameters:
    value: '"../test_data/sms_downlink_tail"'
  states: {}
- name: input_sigmf_entry
  id: variable_qtgui_entry
  parameters:
    gui_hint: 0,0,1,6
    label: SigMF Data filepath
    type: string
    value: input_file_name
  states: {}
- name: sdr_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,3,1,3
    rangeType: int
    start: '-16'
    step: '1'
    stop: '60'
    value: rx_gain
  states: {}
- name: sigmf_file_replay
  id: variable_qtgui_check_box
  parameters:
    'false': 'False'
    gui_hint: 0,7,1,1
    label: Enable SigMF file replay
    'true': 'True'
    type: bool
    value: sigmf_enable
  states: {}
- name: bladeRF_source_0
  id: bladeRF_source
  parameters:
    bias_tee0: 'False'
    bias_tee1: 'False'
    buffers: '512'
    buflen: '4096'
    bw: samp_rate_in
    dac: '10000'
    dc_calibration: LPF_TUNING
    dc_offset_mode0: '0'
    dc_offset_mode1: '0'
    device_id: serial_id
    feature: default
    fpga_image: ''
    fpga_reload: 'False'
    freq: input_rx_freq
    gain0: sdr_gain
    gain1: '10'
    gain_mode0: 'False'
    gain_mode1: 'False'
    if_gain0: sdr_gain
    if_gain1: '20'
    in_clk: ONBOARD
    iq_balance_mode0: '0'
    iq_balance_mode1: '0'
    lpf_mode: disabled
    metadata: 'False'
    nchan: '1'
    out_clk: 'False'
    ref_clk: 10e6
    sample_format: 16bit
    sample_rate: samp_rate_in
    sampling: internal
    show_pmic: 'False'
    smb: 38.4e6
    tamer: internal
    trigger0: 'False'
    trigger1: 'False'
    trigger_role0: master
    trigger_role1: master
    trigger_signal0: J51_1
    trigger_signal1: J51_1
    use_dac: 'False'
    use_ref_clk: 'False'
    verbosity: verbose
    xb200: none
  states: {}
- name: blocks_abs_xx_0_0
  id: blocks_abs_xx
  parameters:
    type: short
  states: {}
- name: blocks_complex_to_interleaved_short_1
  id: blocks_complex_to_interleaved_short
  parameters:
    scale_factor: '2047'
    vector_output: 'False'
  states: {}
- name: blocks_interleaved_short_to_complex_0
  id: blocks_interleaved_short_to_complex
  parameters:
    scale_factor: '2047'
    vector_input: 'False'
  states: {}
- name: blocks_interleaved_short_to_complex_0_0_0
  id: blocks_interleaved_short_to_complex
  parameters:
    scale_factor: '2047.0'
    vector_input: 'False'
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: sigmf_file_replay
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: complex
  states: {}
- name: blocks_sigmf_source_minimal_0
  id: blocks_sigmf_source_minimal
  parameters:
    file: input_sigmf_entry
    repeat: 'True'
    type: complex short (sc16_le)
  states: {}
- name: blocks_throttle2_1
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate_in
    type: complex
  states: {}
- name: fc
  id: parameter
  parameters:
    label: fc
    type: eng_float
    value: 910e6
  states: {}
- name: gsm_bcch_ccch_demapper_0
  id: gsm_bcch_ccch_demapper
  parameters:
    timeslot_nr: '0'
  states: {}
- name: gsm_clock_offset_control_1
  id: gsm_clock_offset_control
  parameters:
    fc: fc
    osr: osr
    samp_rate: samp_rate_in
  states: {}
- name: gsm_control_channels_decoder_0
  id: gsm_control_channels_decoder
  parameters: {}
  states: {}
- name: gsm_input_1
  id: gsm_input
  parameters:
    ppm: '0'
  states: {}
- name: gsm_message_printer_0
  id: gsm_message_printer
  parameters:
    prepend_fnr: 'False'
    prepend_frame_count: 'False'
    prepend_string: '""'
    print_gsmtap_header: 'False'
  states: {}
- name: gsm_receiver_1
  id: gsm_receiver
  parameters:
    osr: '4'
  states: {}
- name: input_file_name
  id: parameter
  parameters:
    short_id: i
    type: str
    value: '"../test_data/gsm_downlink_BCCH_tail.sigmf-data"'
  states: {}
- name: network_socket_pdu_0
  id: network_socket_pdu
  parameters:
    host: 127.0.0.1
    mtu: '10000'
    port: '4729'
    type: UDP_CLIENT
  states: {}
- name: network_socket_pdu_1
  id: network_socket_pdu
  parameters:
    comment: added in order to avoid generating ICMP messages
    host: 127.0.0.1
    mtu: '10000'
    port: '4729'
    type: UDP_SERVER
  states: {}
- name: osr
  id: parameter
  parameters:
    label: OSR
    type: intx
    value: '4'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate_in
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '1024'
    gui_hint: 2,0,1,6
    type: complex
    wintype: window.WIN_HANN
    ymin: '-120'
  states: {}
- name: qtgui_time_raster_sink_x_0
  id: qtgui_time_raster_sink_x
  parameters:
    color1: '5'
    gui_hint: 2,7,1,1
    name: '"GSM decoded bits (if flashing signal is GSM"'
    ncols: '1'
    samp_rate: samp_rate_in
    type: msg_byte
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    gui_hint: 9,0,1,6
    label1: I
    label2: Q
    name: Max IQ value Stream (scaled by 2048)
    size: 4096*64
    srate: samp_rate_in
    type: complex
    update_time: '0.08'
    ymin: '0'
  states: {}
- name: rx_gain
  id: parameter
  parameters:
    label: gain
    short_id: g
    type: intx
    value: '20'
  states: {}
- name: samp_rate_in
  id: parameter
  parameters:
    label: fs
    type: eng_float
    value: 1e6
  states: {}
- name: serial_id
  id: parameter
  parameters:
    label: serial
    short_id: s
    type: str
    value: '""'
  states: {}
- name: sigmf_enable
  id: parameter
  parameters:
    short_id: e
    type: intx
    value: '0'
  states: {}

connections:
- [bladeRF_source_0, '0', blocks_selector_0, '0']
- [blocks_abs_xx_0_0, '0', blocks_interleaved_short_to_complex_0, '0']
- [blocks_complex_to_interleaved_short_1, '0', blocks_abs_xx_0_0, '0']
- [blocks_interleaved_short_to_complex_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_interleaved_short_to_complex_0_0_0, '0', blocks_throttle2_1, '0']
- [blocks_selector_0, '0', blocks_complex_to_interleaved_short_1, '0']
- [blocks_selector_0, '0', gsm_input_1, '0']
- [blocks_selector_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_sigmf_source_minimal_0, '0', blocks_interleaved_short_to_complex_0_0_0, '0']
- [blocks_throttle2_1, '0', blocks_selector_0, '1']
- [gsm_bcch_ccch_demapper_0, bursts, gsm_control_channels_decoder_0, bursts]
- [gsm_clock_offset_control_1, ctrl, gsm_input_1, ctrl_in]
- [gsm_control_channels_decoder_0, msgs, gsm_message_printer_0, msgs]
- [gsm_control_channels_decoder_0, msgs, network_socket_pdu_0, pdus]
- [gsm_control_channels_decoder_0, msgs, qtgui_time_raster_sink_x_0, in]
- [gsm_input_1, '0', gsm_receiver_1, '0']
- [gsm_receiver_1, C0, gsm_bcch_ccch_demapper_0, bursts]
- [gsm_receiver_1, measurements, gsm_clock_offset_control_1, measurements]

metadata:
  file_format: 1
  grc_version: 3.10.12.0
