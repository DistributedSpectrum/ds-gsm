options:
  parameters:
    author: Bradley C.
    description: Use this function to read in a cfile IQ file and scale it for bladeRF 12bit. Hit write sigmf checkbox to lock in data
    generate_options: qt_gui
    id: scale_gsm_for_12bit
    output_language: python
    title: Scale cfile to 12bit
  states: {}

blocks:
- name: bcc_tch_filter
  id: variable_qtgui_check_box
  parameters:
    'false': '0'
    gui_hint: 2,2,1,1
    label: Channel Filter (BCCH/TCH) Select
    'true': '1'
    type: int
    value: '0'
  states: {}
- name: filter_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,0,1,2
    label: filt_gain
    rangeType: int
    start: '1'
    step: '1'
    stop: '300'
    value: '29'
  states: {}
- name: gsm_sample_rate
  id: variable
  parameters:
    value: (270.8334e3 + 8e3)/2
  states: {}
- name: input_cfile_entry
  id: variable_qtgui_entry
  parameters:
    gui_hint: 0,0,1,2
    label: Cfile Data filepath
    type: string
    value: input_file_name
  states: {}
- name: n_iq
  id: variable
  parameters:
    value: int(os.path.getsize(input_cfile_entry) // gr.sizeof_gr_complex)*2
  states: {}
- name: os
  id: variable
  parameters:
    value: __import__('os')
  states: {}
- name: output_sigmf_entry
  id: variable_qtgui_entry
  parameters:
    gui_hint: 0,2,1,2
    label: SigMf Data outpath
    type: string
    value: output_file_name
  states: {}
- name: sample_rate_switch
  id: variable_qtgui_toggle_switch
  parameters:
    gui_hint: 1,2,1,1
    initPressed: 'False'
    label: BCCH/TCH Fs
    outputmsgname: pmt.to_pmt(True)
    pressed: 100.0e6/174
    released: 1e6
    type: real
    value: samp_rate_in
  states: {}
- name: variable_qtgui_entry_0
  id: variable_qtgui_entry
  parameters:
    entry_signal: returnPressed
    gui_hint: 1,1,1,1
    label: sample rate
    type: real
    value: sample_rate_switch
  states: {}
- name: write_to_sigmf
  id: variable_qtgui_check_box
  parameters:
    'false': '0'
    gui_hint: 1,0,1,1
    label: Write to Sigmf
    'true': '1'
    type: int
    value: '0'
  states: {}
- name: blocks_abs_xx_0_0
  id: blocks_abs_xx
  parameters:
    type: short
  states: {}
- name: blocks_complex_to_interleaved_short_0
  id: blocks_complex_to_interleaved_short
  parameters:
    scale_factor: '2047.0'
    vector_output: 'False'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    begin_tag: pmt.intern("file_begin")
    file: input_cfile_entry
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_head_0
  id: blocks_head
  parameters:
    num_items: n_iq
    type: short
  states: {}
- name: blocks_interleaved_short_to_complex_0
  id: blocks_interleaved_short_to_complex
  parameters:
    scale_factor: '2047'
    vector_input: 'False'
  states: {}
- name: blocks_interleaved_short_to_complex_0_0
  id: blocks_interleaved_short_to_complex
  parameters:
    scale_factor: '2047.0'
    vector_input: 'False'
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: short
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: '0'
    num_inputs: '1'
    num_outputs: '2'
    output_index: write_to_sigmf
    showports: 'False'
    type: short
  states: {}
- name: blocks_selector_0_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: bcc_tch_filter
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    showports: 'False'
    type: complex
  states: {}
- name: blocks_sigmf_sink_minimal_0
  id: blocks_sigmf_sink_minimal
  parameters:
    center_freq: fc
    description: 'Signal should be centered around TX Freq. Signal BW ~= 280kHz Generated using sms_multirtl_downlink_tail.cfile scaled to 12bit. '
    filename: output_sigmf_entry
    sample_rate: sample_rate_switch
    type: complex short (sc16_le)
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: sample_rate_switch
    type: complex
  states: {}
- name: fc
  id: parameter
  parameters:
    label: fc
    type: eng_float
    value: 910e6
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '.0'
    comment: filter for SMS BCCH file
    decim: '1'
    samp_rate: 1e6
    taps: firdes.low_pass(filter_gain,1e6,gsm_sample_rate,gsm_sample_rate*.2)
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '0'
    comment: old filter for BCCH
    decim: '1'
    samp_rate: samp_rate_in
    taps: firdes.low_pass(filter_gain,samp_rate_in, 0.136e6 , 100e3)
    type: ccc
  states: {state: disabled}
- name: freq_xlating_fir_filter_xxx_0_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '0'
    comment: filter for TCH
    decim: '1'
    samp_rate: 100e6/174
    taps: firdes.low_pass(filter_gain,100e6/174, 190e3, 20e3)
    type: ccc
  states: {}
- name: input_file_name
  id: parameter
  parameters:
    comment: Cant seem to change the file when running the GUI. Just change here
    short_id: i
    type: str
    value: ../test_data/sms_multirtl_downlink_tail.cfile
  states: {}
- name: output_file_name
  id: parameter
  parameters:
    comment: Cant seem to change the file when running the GUI. Just change here
    short_id: o
    type: str
    value: ../test_data/gsm_downlink_BCCH_tail
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: sample_rate_switch
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    gui_hint: 0,4,2,2
    name: '"Cfile Input PSD"'
    type: complex
    wintype: window.WIN_HANN
    ymax: '-40'
    ymin: '-100'
  states: {}
- name: qtgui_freq_sink_x_0_0_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: sample_rate_switch
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '4096'
    grid: 'True'
    gui_hint: 3,0,2,2
    name: '"SigMF Output PSD"'
    showports: 'True'
    type: complex
    update_time: '0.01'
    wintype: window.WIN_HAMMING
    ymax: '-0'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    gui_hint: 3,2,2,2
    label1: I
    label2: Q
    name: Max IQ value SigMF (scaled by 2048)
    size: 4096*64
    srate: sample_rate_switch
    type: complex
    update_time: '0.08'
    ymin: '0'
  states: {}
- name: samp_rate_in
  id: parameter
  parameters:
    label: fs
    type: eng_float
    value: 1e6
  states: {}

connections:
- [blocks_abs_xx_0_0, '0', blocks_interleaved_short_to_complex_0, '0']
- [blocks_complex_to_interleaved_short_0, '0', blocks_abs_xx_0_0, '0']
- [blocks_complex_to_interleaved_short_0, '0', blocks_interleaved_short_to_complex_0_0, '0']
- [blocks_complex_to_interleaved_short_0, '0', blocks_selector_0, '0']
- [blocks_file_source_0, '0', blocks_throttle2_0, '0']
- [blocks_head_0, '0', blocks_sigmf_sink_minimal_0, '0']
- [blocks_interleaved_short_to_complex_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_interleaved_short_to_complex_0_0, '0', qtgui_freq_sink_x_0_0_0, '0']
- [blocks_selector_0, '0', blocks_null_sink_0, '0']
- [blocks_selector_0, '1', blocks_head_0, '0']
- [blocks_selector_0_0, '0', blocks_complex_to_interleaved_short_0, '0']
- [blocks_throttle2_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [blocks_throttle2_0, '0', freq_xlating_fir_filter_xxx_0_0, '0']
- [blocks_throttle2_0, '0', freq_xlating_fir_filter_xxx_0_0_0, '0']
- [blocks_throttle2_0, '0', qtgui_freq_sink_x_0_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', blocks_selector_0_0, '0']
- [freq_xlating_fir_filter_xxx_0_0, '0', blocks_selector_0_0, '0']
- [freq_xlating_fir_filter_xxx_0_0_0, '0', blocks_selector_0_0, '1']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
