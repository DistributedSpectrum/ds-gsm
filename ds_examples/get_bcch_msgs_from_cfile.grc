options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: get_bcch_msgs_from_cfile
    output_language: python
    run_options: run
  states: {}

blocks:
- name: filter_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,2,1,1
    label: filt_gain
    rangeType: int
    start: '1'
    step: '1'
    stop: '300'
    value: '29'
  states: {state: disabled}
- name: freq_rx
  id: variable_qtgui_entry
  parameters:
    gui_hint: 0,0,1,2
    label: Frequency rx
    type: real
    value: fc
  states: {state: disabled}
- name: freq_shift
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,5,1,1
    label: freq shift
    start: '-samp_rate/2'
    step: '1'
    stop: samp_rate/2
    value: '0'
  states: {state: disabled}
- name: freq_tx
  id: variable_qtgui_entry
  parameters:
    gui_hint: 0,3,1,2
    label: Frequency tx
    type: real
    value: fc
  states: {state: disabled}
- name: sdr_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,8,1,1
    label: gain
    rangeType: int
    start: '0'
    step: '1'
    stop: '50'
    value: '10'
  states: {state: disabled}
- name: tx_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,9,1,1
    label: gain_tx
    start: '-23.75'
    step: '.25'
    stop: '66'
    value: '12'
  states: {state: disabled}
- name: blocks_abs_xx_0
  id: blocks_abs_xx
  parameters:
    type: float
  states: {}
- name: blocks_abs_xx_0_0
  id: blocks_abs_xx
  parameters:
    type: float
  states: {}
- name: blocks_complex_to_imag_0
  id: blocks_complex_to_imag
  parameters: {}
  states: {}
- name: blocks_complex_to_interleaved_short_0
  id: blocks_complex_to_interleaved_short
  parameters:
    scale_factor: '2047.0'
    vector_output: 'False'
  states: {state: disabled}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/subrad/work/gsm_work/gr-gsm/test_data/sms_multirtl_downlink_tail.cfile
    repeat: 'False'
    type: complex
  states: {state: disabled}
- name: blocks_interleaved_short_to_complex_0_0
  id: blocks_interleaved_short_to_complex
  parameters:
    scale_factor: '2047.0'
    vector_input: 'False'
  states: {state: disabled}
- name: blocks_interleaved_short_to_complex_0_0_0
  id: blocks_interleaved_short_to_complex
  parameters:
    scale_factor: '2047.0'
    vector_input: 'False'
  states: {state: disabled}
- name: blocks_max_xx_0
  id: blocks_max_xx
  parameters:
    num_inputs: '2'
    type: float
  states: {}
- name: blocks_sigmf_sink_minimal_0
  id: blocks_sigmf_sink_minimal
  parameters:
    center_freq: freq_tx
    description: 'Signal should be centered around TX Freq. Signal BW ~= 280kHz Generated using sms_multirtl_downlink_tail.cfile scaled to 12bit. '
    filename: gsm_downlink_BCCH_tail
    sample_rate: samp_rate
    type: complex short (sc16_le)
  states: {state: disabled}
- name: blocks_sigmf_source_minimal_0
  id: blocks_sigmf_source_minimal
  parameters:
    file: /home/subrad/work/gsm_work/gr-gsm/examples/get_bcch_msgs_from_cfile/gsm_downlink_BCCH_tail.sigmf-data
    repeat: 'True'
    type: complex short (sc16_le)
  states: {state: disabled}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: blocks_throttle2_1
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: fc
  id: parameter
  parameters:
    label: fc
    short_id: f
    type: eng_float
    value: 937e6
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '.0'
    decim: '1'
    samp_rate: samp_rate
    taps: firdes.low_pass(filter_gain,samp_rate,0.136e6, 50e3)
    type: ccc
  states: {state: disabled}
- name: gsm_bcch_ccch_demapper_0
  id: gsm_bcch_ccch_demapper
  parameters:
    timeslot_nr: '0'
  states: {}
- name: gsm_clock_offset_control_0
  id: gsm_clock_offset_control
  parameters:
    fc: fc
    osr: osr
    samp_rate: samp_rate
  states: {}
- name: gsm_control_channels_decoder_0
  id: gsm_control_channels_decoder
  parameters: {}
  states: {}
- name: gsm_input_0
  id: gsm_input
  parameters:
    ppm: '0'
    samp_rate_in: samp_rate
  states: {}
- name: gsm_message_printer_0
  id: gsm_message_printer
  parameters:
    prepend_fnr: 'False'
    prepend_frame_count: 'False'
    prepend_string: '""'
    print_gsmtap_header: 'False'
  states: {}
- name: gsm_receiver_0
  id: gsm_receiver
  parameters:
    osr: '4'
  states: {}
- name: input_file_name
  id: parameter
  parameters:
    label: input_file_name
    short_id: i
    value: input.cfile
  states: {state: disabled}
- name: network_socket_pdu_0
  id: network_socket_pdu
  parameters:
    host: 127.0.0.1
    mtu: '10000'
    port: '4729'
    type: UDP_CLIENT
  states: {}
- name: network_socket_pdu_1
  id: network_socket_pdu
  parameters:
    comment: added in order to avoid generating ICMP messages
    host: 127.0.0.1
    mtu: '10000'
    port: '4729'
    type: UDP_SERVER
  states: {}
- name: osmosdr_sink_0_0
  id: osmosdr_sink
  parameters:
    args: '"bladerf=e62e229e5a6a41cbba874004a2856b27"'
    bb_gain0: tx_gain
    bw0: samp_rate
    freq0: freq_tx
    gain0: tx_gain
    if_gain0: tx_gain
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {state: disabled}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: '"bladerf=c4af21dcdf8547d79fa1e9e475082cd3"'
    bb_gain0: sdr_gain
    bw0: samp_rate
    freq0: fc
    gain0: sdr_gain
    gain_mode0: 'False'
    if_gain0: sdr_gain
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: osr
  id: parameter
  parameters:
    label: OSR
    type: intx
    value: '4'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '1024'
    gui_hint: 1,0,1,6
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.1'
    bw: samp_rate
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '1024'
    gui_hint: 1,6,1,6
    name: '"1"'
    type: complex
  states: {state: disabled}
- name: qtgui_freq_sink_x_0_0_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    bw: samp_rate
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '4096'
    grid: 'True'
    gui_hint: 1,12,1,6
    name: '"IF"'
    showports: 'True'
    type: complex
    update_time: '0.01'
    wintype: window.WIN_HAMMING
    ymax: '-30'
    ymin: '-160'
  states: {state: disabled}
- name: qtgui_time_sink_x_0_1
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    grid: 'True'
    label1: Max
    name: '"pre_scale"'
    size: 4096*64
    srate: samp_rate
    type: float
    update_time: '.8'
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    label: samp_rate
    short_id: s
    type: eng_float
    value: 1e6
  states: {}
- name: symbol_rate
  id: parameter
  parameters:
    label: symbol_rate
    short_id: y
    type: eng_float
    value: 270.9e3
  states: {}

connections:
- [blocks_abs_xx_0, '0', blocks_max_xx_0, '1']
- [blocks_abs_xx_0_0, '0', blocks_max_xx_0, '0']
- [blocks_complex_to_imag_0, '0', blocks_abs_xx_0, '0']
- [blocks_complex_to_interleaved_short_0, '0', blocks_interleaved_short_to_complex_0_0, '0']
- [blocks_complex_to_interleaved_short_0, '0', blocks_sigmf_sink_minimal_0, '0']
- [blocks_complex_to_real_0, '0', blocks_abs_xx_0_0, '0']
- [blocks_file_source_0, '0', blocks_throttle2_0, '0']
- [blocks_interleaved_short_to_complex_0_0, '0', osmosdr_sink_0_0, '0']
- [blocks_interleaved_short_to_complex_0_0, '0', qtgui_freq_sink_x_0_0_0, '0']
- [blocks_interleaved_short_to_complex_0_0_0, '0', blocks_throttle2_1, '0']
- [blocks_max_xx_0, '0', qtgui_time_sink_x_0_1, '0']
- [blocks_sigmf_source_minimal_0, '0', blocks_interleaved_short_to_complex_0_0_0, '0']
- [blocks_throttle2_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [blocks_throttle2_0, '0', qtgui_freq_sink_x_0_0, '0']
- [blocks_throttle2_1, '0', gsm_input_0, '0']
- [blocks_throttle2_1, '0', qtgui_freq_sink_x_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', blocks_complex_to_interleaved_short_0, '0']
- [gsm_bcch_ccch_demapper_0, bursts, gsm_control_channels_decoder_0, bursts]
- [gsm_clock_offset_control_0, ctrl, gsm_input_0, ctrl_in]
- [gsm_control_channels_decoder_0, msgs, gsm_message_printer_0, msgs]
- [gsm_control_channels_decoder_0, msgs, network_socket_pdu_0, pdus]
- [gsm_input_0, '0', gsm_receiver_0, '0']
- [gsm_receiver_0, C0, gsm_bcch_ccch_demapper_0, bursts]
- [gsm_receiver_0, measurements, gsm_clock_offset_control_0, measurements]
- [osmosdr_source_0, '0', gsm_input_0, '0']
- [osmosdr_source_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
