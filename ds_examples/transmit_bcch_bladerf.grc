options:
  parameters:
    author: Bradley C.
    generate_options: qt_gui
    id: transmit_bcch_bladerf
    output_language: python
    title: 'GSM BCCH Transmitter bladeRF/SigMF '
  states: {}

blocks:
- name: freq_tx
  id: variable_qtgui_entry
  parameters:
    gui_hint: 1,0,1,3
    label: Frequency tx
    type: real
    value: fc
  states: {}
- name: input_sigmf
  id: variable
  parameters:
    value: '"../test_data/sms_downlink_tail"'
  states: {}
- name: input_sigmf_entry
  id: variable_qtgui_entry
  parameters:
    gui_hint: 0,0,1,6
    label: SigMF Data filepath
    type: string
    value: input_file_name
  states: {}
- name: tx_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,3,1,3
    start: '-23.75'
    step: '.25'
    stop: '66'
    value: tx_gain_in
  states: {}
- name: bladeRF_sink_0
  id: bladeRF_sink
  parameters:
    bias_tee0: 'True'
    bias_tee1: 'False'
    buffers: '512'
    buflen: '4096'
    bw: samp_rate
    dac: '10000'
    dc_calibration: LPF_TUNING
    dc_i0: '0'
    dc_i1: '0'
    dc_q0: '0'
    dc_q1: '0'
    device_id: serial_id
    feature: default
    fpga_image: ''
    fpga_reload: 'False'
    freq: freq_tx
    gain0: tx_gain
    gain1: '10'
    if_gain0: tx_gain
    if_gain1: '20'
    in_clk: ONBOARD
    iq_gain0: '0'
    iq_gain1: '0'
    iq_phase0: '0'
    iq_phase1: '0'
    lpf_mode: disabled
    metadata: 'False'
    nchan: '1'
    out_clk: 'False'
    ref_clk: 10e6
    sample_format: 16bit
    sample_rate: samp_rate
    sampling: internal
    show_pmic: 'False'
    smb: 38.4e6
    tamer: internal
    trigger0: 'False'
    trigger1: 'False'
    trigger_role0: master
    trigger_role1: master
    trigger_signal0: J51_1
    trigger_signal1: J51_1
    use_dac: 'False'
    use_ref_clk: 'False'
    verbosity: verbose
    xb200: none
  states: {}
- name: blocks_abs_xx_0_0
  id: blocks_abs_xx
  parameters:
    type: short
  states: {}
- name: blocks_interleaved_short_to_complex_0
  id: blocks_interleaved_short_to_complex
  parameters:
    scale_factor: '2047'
    vector_input: 'False'
  states: {}
- name: blocks_interleaved_short_to_complex_0_0_0
  id: blocks_interleaved_short_to_complex
  parameters:
    scale_factor: '2047.0'
    vector_input: 'False'
  states: {}
- name: blocks_sigmf_source_minimal_0
  id: blocks_sigmf_source_minimal
  parameters:
    file: input_sigmf_entry
    repeat: 'True'
    type: complex short (sc16_le)
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: fc
  id: parameter
  parameters:
    label: fc
    type: eng_float
    value: 910e6
  states: {}
- name: input_file_name
  id: parameter
  parameters:
    short_id: i
    type: str
    value: '"../test_data/gsm_downlink_BCCH_tail.sigmf-data"'
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.1'
    bw: samp_rate
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '2048'
    gui_hint: 2,0,1,6
    name: '"Freq Domain of SigMF"'
    type: complex
    wintype: window.WIN_HANN
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    gui_hint: 9,0,1,6
    label1: I
    label2: Q
    name: Max IQ value SigMF (scaled by 2048)
    size: 4096*64
    srate: samp_rate
    type: complex
    update_time: '0.08'
    ymin: '0'
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    hide: part
    label: fs
    type: eng_float
    value: 1e6
  states: {}
- name: serial_id
  id: parameter
  parameters:
    label: serial
    short_id: s
    type: str
    value: '""'
  states: {}
- name: tx_gain_in
  id: parameter
  parameters:
    label: gain
    short_id: g
    type: intx
    value: '16'
  states: {}

connections:
- [blocks_abs_xx_0_0, '0', blocks_interleaved_short_to_complex_0, '0']
- [blocks_interleaved_short_to_complex_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_interleaved_short_to_complex_0_0_0, '0', blocks_throttle2_0, '0']
- [blocks_sigmf_source_minimal_0, '0', blocks_abs_xx_0_0, '0']
- [blocks_sigmf_source_minimal_0, '0', blocks_interleaved_short_to_complex_0_0_0, '0']
- [blocks_throttle2_0, '0', bladeRF_sink_0, '0']
- [blocks_throttle2_0, '0', qtgui_freq_sink_x_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
